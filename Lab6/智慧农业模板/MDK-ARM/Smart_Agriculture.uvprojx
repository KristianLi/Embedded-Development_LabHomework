# Keil uVision project Smart_Agriculture.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F407ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x300000) IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 03_EEPROM_OLED
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\GD32F4x_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\..\..\..\GD32F4x_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\USER;..\..\..\Utilities;..\Soft_Drive\EEPROM;..\Soft_Drive\OLED;..\Soft_Drive\test_platform;..\..\..\..\GD32F4x_Firmware_Library\CMSIS;..\..\..\..\GD32F4x_Firmware_Library\XLL_4G;..\Soft_Drive\I2C;..\Soft_Drive\E53_IA1;..\Soft_Drive\platfrom_test;..\Soft_Drive\74HC595;..\Soft_Drive\pwm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../USER/: gd32f4xx_it.c main.c systick.c
  group CMSIS
    ../../../../GD32F4x_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4x_Peripherals
    ../../../../GD32F4x_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Xll-IOT(GD32)
    ../../../Utilities/: gd32f4xx_XII-IOT.c
  group Startup
    ../../../../GD32F4x_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407.s
  group Soft_Drive
    ../Soft_Drive/OLED/: oled.c
    ../Soft_Drive/EEPROM/: at24cxx.c
    ../Soft_Drive/I2C/: I2C.c
    ../Soft_Drive/E53_IA1/: E53_IA1.c
    ../Soft_Drive/platfrom_test/: test.c
    ../Soft_Drive/74HC595/: 74HC595_LED.c
    ../Soft_Drive/pwm/: pwm.c
  group Doc
    ../Doc/: Readme.txt
  group 4g_XLL
    ../../../../GD32F4x_Firmware_Library/XLL_4G/: cJSON.c cJSON_Utils.c crc16.c message_json.c sim7600ce.c usart2.c
